# Keil uVision project M4_Project.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: M4_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\Users\dell\AppData\Local\Arm\Packs\Keil\STM32F1xx_DFP\2.4.1\Device\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c main.h
  group MCAL_REGISTERS_DEFINITIONS
    ./MCAL_Layer/REGISTERS_DEFINITIONS/: REGISTERS_DEFINITIONS.h
    ./MCAL_Layer/: std_types.h
    ./: stm32f10c8.h
  group MCAL_GPIO
    ./MCAL_Layer/GPIO/: MCAL_GPIO.c MCAL_GPIO.h
  group MCAL_RCC
    ./MCAL_Layer/RCC_CLOCK/: MCAL_RCC.c MCAL_RCC.h
  group MCAL_TIMERS
    ./MCAL_Layer/TIMERS/General_Purpose_Timers/: MCAL_TIMER2.c MCAL_TIMER3.h MCAL_TIMER2.h MCAL_TIMER3.c MCAL_TIMER4.c MCAL_TIMER4.h MCAL_TIMER1.c MCAL_TIMER1.h MCAL_TIMERS.c MCAL_TIMERS.h
    ./MCAL_Layer/TIMERS/: MCAL_TIMERS_GEN_CFG.h
  group MCAL_INTERRUPTS
    ./MCAL_Layer/INTERRUPT/: MCAL_EXTERNAL_INTERRUPTS.c MCAL_EXTERNAL_INTERRUPTS.h MCAL_NVIC.h MCAL_INTERNAL_INTERRUPTS.c MCAL_INTERNAL_INTERRUPTS.h
  group MCAL_USART
    ./MCAL_Layer/UART/: MCAL_UART.c MCAL_UART.h
  group HAL_SERVO
    ./HAL_Layer/SERVO_MOTOR/: HAL_SERVO.c HAL_SERVO.h
  group HAL_DC_MOTOR
    ./HAL_Layer/DC_MOTOR/: HAL_DC_MOTOR.c HAL_DC_MOTOR.h
  group HAL_ENCODER
    ./HAL_Layer/ENCODER/: HAL_ENCODER.c HAL_ENCODER.h
  group Softwares
    ./Softwares/: M4_Softwares.c M4_Softwares.h
  group MCAL_SPI
    ./MCAL_Layer/SPI/: MCAL_SPI_GEN_CFG.h MCAL_SPI1.c MCAL_SPI1.h MCAL_SPI2.c MCAL_SPI2.h
  group HAL_NRF24L01
    ./HAL_Layer/NRF24L01/: NRF24L01.c NRF24L01.h
  group MCAL_ADC
    ./MCAL_Layer/ADC/: MCAL_ADC.c MCAL_ADC.h
target Target 2 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: M4_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.0
